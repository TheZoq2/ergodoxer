# Repository TheZoq2/ergodoxer

## KiCad design neutron-c/neutron-c.kicad_pcb

Parts:
B0, B1: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged2Bar12_RoundedPad1.0x1.5mm
C1: C; C_0402
C2, C3: 100p; C_0402
C4, C5: 12p; C_0402
C6: 100n; R_0402
C7: 10uF1; C_0402
C8: 10uF2; C_0402
D1: LED_green; LED_0402
D2: LED_red; LED_0402
J1, J4: Conn_01x20; Pin_Header_Straight_1x20_Pitch2.54mm
J6: Conn_01x04_Male; Pin_Header_Straight_1x04_Pitch2.54mm
J7: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 10k; R_0402
R2, R3: 670; R_0402
R4: 1.5k; R_0402
R5, R6: 22R; R_0402
R7, R8: 100k; R_0402
R9, R10: 5.1k; R_0402_NoSilk
SW1: SW_Push; SW_DIP_x1_W7.62mm_Slide
U1: STM32F103RGTx; LQFP-64_10x10mm_Pitch0.5mm
U2: LM1117-3.3; SOT-23
Y1: 32k768; Crystal_SMD_2012-2pin_2.0x1.2mm_HandSoldering
Y2: 8M0; Crystal_SMD_2012-2pin_2.0x1.2mm_HandSoldering

Connections:
+3V3: B0.3 (B), B1.3 (B), C1.1, C8.1, J1.20, J4.3, J6.1, JP2.1 (A), R1.2, R4.2, U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.2 (VO)
+5V: C7.1, J1.18, J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS), U2.3 (VI)
BOOT0: R8.2, U1.60 (BOOT0)
BOOT1: R7.2, U1.28 (PB2)
DCLK: J6.3, U1.49 (PA14)
DIO: J6.2, U1.46 (PA13)
GND: B0.1 (A), B1.1 (A), C1.2, C2.2, C3.1, C4.2, C5.1, C6.1, C7.2, C8.2, D1.1 (K), D2.1 (K), J1.19, J4.1, J4.2, J6.4, J7.A1 (GND), J7.A12 (GND), J7.B1 (GND), J7.B12 (GND), J7.S1 (SHIELD), R9.2, R10.2, SW1.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.1 (GND)
NRST: C6.2, J4.4, R1.1, SW1.1, U1.7 (NRST)
unnamed: B0.2 (C), R8.1
unnamed: B1.2 (C), R7.1
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R3.2
unnamed: J7.A5 (CC1), R10.1
unnamed: J7.B5 (CC2), R9.1
unnamed: JP2.2 (B), R3.1
PA0: J4.16, U1.14 (PA0)
PA1: J4.15, U1.15 (PA1)
PA2: J4.14, U1.16 (PA2)
PA3: J4.13, U1.17 (PA3)
PA4: J4.12, U1.20 (PA4)
PA5: J4.11, U1.21 (PA5)
PA6: J4.10, U1.22 (PA6)
PA7: J4.9, U1.23 (PA7)
PA8: J1.5, U1.41 (PA8)
PA9: J1.6, U1.42 (PA9)
PA10: J1.7, U1.43 (PA10)
PA11: J1.8, R5.2, U1.44 (PA11)
PA12: J1.9, R4.1, R6.2, U1.45 (PA12)
PA15: J1.10, U1.50 (PA15)
PB0: J4.8, R2.1, U1.26 (PB0)
PB1: J4.7, U1.27 (PB1)
PB3: J1.11, U1.55 (PB3)
PB4: J1.12, U1.56 (PB4)
PB5: J1.13, U1.57 (PB5)
PB6: J1.14, U1.58 (PB6)
PB7: J1.15, U1.59 (PB7)
PB8: J1.16, U1.61 (PB8)
PB9: J1.17, U1.62 (PB9)
PB10: J4.6, U1.29 (PB10)
PB11: J4.5, U1.30 (PB11)
PB12: J1.1, U1.33 (PB12)
PB13: J1.2, U1.34 (PB13)
PB14: J1.3, U1.35 (PB14)
PB15: J1.4, U1.36 (PB15)
PC13: J4.19, U1.2 (PC13)
PC14: C2.1, J4.18, U1.3 (PC14), Y1.1
PC15: C3.2, J4.17, U1.4 (PC15), Y1.2
PD0: C4.1, U1.5 (PD0), Y2.1
PD1: C5.2, U1.6 (PD1), Y2.2
USB_DM: J7.A7 (D-), J7.B7 (D-), R5.1
USB_DP: J7.A6 (D+), J7.B6 (D+), R6.1
VBAT: J4.20, U1.1 (VBAT)

Notes on the sheet:
USB port
SVD port
PSU
Reset
Boot selector
Power and user LED
LSE?
HSE?

Board: 2 copper layers, 20.8 x 51.3 mm, 32 parts (0 on the bottom side), 52 nets.

## KiCad design ergodoxer.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D37, D38, D39, D40, D41, D43, D45, D46, D48, D49, D50, D51, D52, D53: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
JP1, JP2, JP3, JP4: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
LE23: WS2812B; LED_WS2812B-inverted
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED37, LED38, LED39, LED40, LED41, LED45, LED46, LED48, LED49, LED50, LED51, LED52, LED53: WS2812B; LED_WS2812B-inverted
LED43: WS2812; LED_WS2812B-inverted
SW1, SW7, SW13, SW19, SW25, SW31, SW37: SW_Push_mod; SW_Cherry_MX_1.00u_PCB_dual
SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW20, SW21, SW22, SW23, SW24, SW26, SW27, SW28, SW29, SW30, SW32, SW33, SW34, SW35, SW38, SW39, SW40, SW41, SW45, SW48, SW49, SW50, SW51, SW52, SW53: SW_Push; SW_Cherry_MX_1.00u_PCB_dual
SW43, SW46: SW_Push; SW_Cherry_MX_2.00u_PCB_reversible
U1: neutron-c

Connections:
CC: J1.A8 (SBU1), J1.B8 (SBU2), JP1.2
D+: J1.A6 (D+), J1.B6 (D+), JP2.2
D-: J1.A7 (D-), J1.B7 (D-), JP4.2
GND: J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), LE23.3 (VSS), LED1.3 (VSS), LED2.3 (VSS), LED3.3 (VSS), LED4.3 (VSS), LED5.3 (VSS), LED6.3 (VSS), LED7.3 (VSS), LED8.3 (VSS), LED9.3 (VSS), LED10.3 (VSS), LED11.3 (VSS), LED12.3 (VSS), LED13.3 (VSS), LED14.3 (VSS), LED15.3 (VSS), LED16.3 (VSS), LED17.3 (VSS), LED18.3 (VSS), LED19.3 (VSS), LED20.3 (VSS), LED21.3 (VSS), LED22.3 (VSS), LED24.3 (VSS), LED25.3 (VSS), LED26.3 (VSS), LED27.3 (VSS), LED28.3 (VSS), LED29.3 (VSS), LED30.3 (VSS), LED31.3 (VSS), LED32.3 (VSS), LED33.3 (VSS), LED34.3 (VSS), LED35.3 (VSS), LED37.3 (VSS), LED38.3 (VSS), LED39.3 (VSS), LED40.3 (VSS), LED41.3 (VSS), LED43.3 (VSS), LED45.3 (VSS), LED46.3 (VSS), LED48.3 (VSS), LED49.3 (VSS), LED50.3 (VSS), LED51.3 (VSS), LED52.3 (VSS), LED53.3 (VSS), U1.19, U1.21, U1.22
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D43.2 (A), SW43.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: LE23.2 (DOUT), LED17.4 (DIN)
unnamed: LE23.4 (DIN), LED29.2 (DOUT)
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED1.4 (DIN), LED7.2 (DOUT)
unnamed: LED2.2 (DOUT), LED8.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED3.4 (DIN), LED9.2 (DOUT)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
unnamed: LED10.2 (DOUT), LED16.4 (DIN)
unnamed: LED4.2 (DOUT), LED10.4 (DIN)
unnamed: LED5.4 (DIN), LED11.2 (DOUT)
unnamed: LED11.4 (DIN), LED17.2 (DOUT)
unnamed: LED12.2 (DOUT), LED18.4 (DIN)
unnamed: LED6.2 (DOUT), LED12.4 (DIN)
unnamed: LED7.4 (DIN), LED13.2 (DOUT)
unnamed: LED13.4 (DIN), LED19.2 (DOUT)
unnamed: LED14.2 (DOUT), LED20.4 (DIN)
unnamed: LED8.2 (DOUT), LED14.4 (DIN)
unnamed: LED9.4 (DIN), LED15.2 (DOUT)
unnamed: LED15.4 (DIN), LED21.2 (DOUT)
unnamed: LED16.2 (DOUT), LED22.4 (DIN)
unnamed: LED18.2 (DOUT), LED24.4 (DIN)
unnamed: LED19.4 (DIN), LED25.2 (DOUT)
unnamed: LED20.2 (DOUT), LED26.4 (DIN)
unnamed: LED21.4 (DIN), LED27.2 (DOUT)
unnamed: LED22.2 (DOUT), LED28.4 (DIN)
unnamed: LED24.2 (DOUT), LED30.4 (DIN)
unnamed: LED25.4 (DIN), LED31.2 (DOUT)
unnamed: LED26.2 (DOUT), LED32.4 (DIN)
unnamed: LED27.4 (DIN), LED33.2 (DOUT)
unnamed: LED28.2 (DOUT), LED34.4 (DIN)
unnamed: LED29.4 (DIN), LED35.2 (DOUT)
unnamed: LED30.2 (DOUT), LED45.4 (DIN)
unnamed: LED31.4 (DIN), LED37.2 (DOUT)
unnamed: LED32.2 (DOUT), LED38.4 (DIN)
unnamed: LED33.4 (DIN), LED39.2 (DOUT)
unnamed: LED34.2 (DOUT), LED40.4 (DIN)
unnamed: LED35.4 (DIN), LED41.2 (DOUT)
unnamed: LED38.2 (DOUT), LED39.4 (DIN)
unnamed: LED40.2 (DOUT), LED41.4 (DIN)
unnamed: LED43.2 (DOUT), LED50.4 (DIN)
unnamed: LED43.4 (DIN), LED46.2 (DOUT)
unnamed: LED45.2 (DOUT), LED48.4 (DIN)
unnamed: LED46.4 (DIN), LED49.2 (DOUT)
unnamed: LED48.2 (DOUT), LED51.4 (DIN)
unnamed: LED49.4 (DIN), LED52.2 (DOUT)
unnamed: LED50.2 (DOUT), LED53.4 (DIN)
unnamed: LED51.2 (DOUT), LED52.4 (DIN)
SBU: J1.A5 (CC1), J1.B5 (CC2), JP3.2
VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), LE23.1 (VDD), LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD), LED15.1 (VDD), LED16.1 (VDD), LED17.1 (VDD), LED18.1 (VDD), LED19.1 (VDD), LED20.1 (VDD), LED21.1 (VDD), LED22.1 (VDD), LED24.1 (VDD), LED25.1 (VDD), LED26.1 (VDD), LED27.1 (VDD), LED28.1 (VDD), LED29.1 (VDD), LED30.1 (VDD), LED31.1 (VDD), LED32.1 (VDD), LED33.1 (VDD), LED34.1 (VDD), LED35.1 (VDD), LED37.1 (VDD), LED38.1 (VDD), LED39.1 (VDD), LED40.1 (VDD), LED41.1 (VDD), LED43.1 (VDD), LED45.1 (VDD), LED46.1 (VDD), LED48.1 (VDD), LED49.1 (VDD), LED50.1 (VDD), LED51.1 (VDD), LED52.1 (VDD), LED53.1 (VDD), U1.18
column1: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, U1.12
column2: SW7.1, SW8.1, SW9.1, SW10.1, SW11.1, SW12.1, U1.13
column3: SW13.1, SW14.1, SW15.1, SW16.1, SW17.1, SW18.1, U1.11
column4: SW19.1, SW20.1, SW21.1, SW22.1, SW23.1, SW24.1, U1.10
column5: SW25.1, SW26.1, SW27.1, SW28.1, SW29.1, SW30.1, SW43.1, U1.3
column6: SW31.1, SW32.1, SW33.1, SW34.1, SW35.1, SW45.1, SW46.1, U1.4
column7: SW37.1, SW38.1, SW39.1, SW40.1, SW41.1, SW48.1, SW49.1, SW50.1, U1.5
column8: SW51.1, SW52.1, SW53.1, U1.15
ledinput: LED37.4 (DIN), U1.29
miso1: U1.30
row1: D1.1 (K), D7.1 (K), D13.1 (K), D19.1 (K), D25.1 (K), D31.1 (K), D37.1 (K), U1.32
row2: D2.1 (K), D8.1 (K), D14.1 (K), D20.1 (K), D26.1 (K), D32.1 (K), D38.1 (K), U1.33
row3: D3.1 (K), D9.1 (K), D15.1 (K), D21.1 (K), D27.1 (K), D33.1 (K), D39.1 (K), U1.34
row4: D4.1 (K), D10.1 (K), D16.1 (K), D22.1 (K), D28.1 (K), D34.1 (K), D40.1 (K), U1.17
row5: D5.1 (K), D11.1 (K), D17.1 (K), D23.1 (K), D29.1 (K), D35.1 (K), D41.1 (K), U1.16
row6: D6.1 (K), D12.1 (K), D18.1 (K), D24.1 (K), D30.1 (K), D50.1 (K), D53.1 (K), U1.36
row7: D45.1 (K), D48.1 (K), D51.1 (K), U1.35
row8: D43.1 (K), D46.1 (K), D49.1 (K), D52.1 (K), U1.14
sclk1: U1.31
uart1_rx: JP3.3, JP4.3, U1.7
uart1_tx: JP1.3, JP2.3, U1.6
uart3_rx: JP1.1, JP2.1, U1.25
uart3_tx: JP3.1, JP4.1, U1.26

Notes on the sheet:
TODO:
LED capacitors
Does keebr support multiple GPIO ports for rows/cols?

Board: 2 copper layers, 197.9 x 173.7 mm, 153 parts (0 on the bottom side), 124 nets.

## Commit log

2019-02-24 Flip switches upside down
2019-02-25 Add leds
2019-02-25 WIP update to square led holes
2019-02-25 Add switches lib
2019-02-25 Add probably generated files just in case
2019-02-27 Add qmk hardware as a submodule and connect thumb cluster
2019-02-27 Redo thumb cluster
2019-08-06 Change microcontroller to neutron c
